# Keil uVision project template.uvproj, settings and files
target template (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: template
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51
    ../User/src/: main.c
